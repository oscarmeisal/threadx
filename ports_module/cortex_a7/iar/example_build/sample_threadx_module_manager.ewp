# IAR project sample_threadx_module_manager.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RM48L952ZWT TexasInstruments RM48L952ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\common\inc; ..\..\..\..\common_modules\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample_threadx_module_manager.srec
  ILINK.IlinkOutputFile: sample_threadx_module_manager.out
  ILINK.IlinkIcfFile: sample_threadx_module_manager.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\common_modules\inc; ..\..\..\..\common\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: C:\Users\cindydeng\AzureRTOS\threadx\modules\cortex-a-port\threadx\ports_module\cortex_a7\iar\example_build\sample_threadx_module_manager.icf
  group (top)
    ./: cstartup.s sample_threadx_module_manager.c tx_initialize_low_level.s
    Debug/Exe/: tx.a
